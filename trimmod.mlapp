classdef trimmod < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        TrimModelUIFigure         matlab.ui.Figure
        FileMenu                  matlab.ui.container.Menu
        OpenModelMenu             matlab.ui.container.Menu
        LoadTrimPointMenu         matlab.ui.container.Menu
        SaveTrimPointMenu         matlab.ui.container.Menu
        SaveTrimPointasMenu       matlab.ui.container.Menu
        ExitTrimModMenu           matlab.ui.container.Menu
        ActionMenu                matlab.ui.container.Menu
        TrimMenu                  matlab.ui.container.Menu
        UntrimMenu                matlab.ui.container.Menu
        OptionsMenu               matlab.ui.container.Menu
        AdditionalParametersMenu  matlab.ui.container.Menu
        ShowOverviewMenu          matlab.ui.container.Menu
        HelpMenu                  matlab.ui.container.Menu
        HelponTrimModMenu         matlab.ui.container.Menu
        AboutTrimModMenu          matlab.ui.container.Menu
        GridLayout                matlab.ui.container.GridLayout
        UITable_output            matlab.ui.control.Table
        UITable_derivative        matlab.ui.control.Table
        UITable_state             matlab.ui.control.Table
        TrimRequirementsLabel     matlab.ui.control.Label
        TrimVariablesLabel        matlab.ui.control.Label
        UITable_input             matlab.ui.control.Table
    end

    properties (Access = private)

        parameters_app
        overview_app
        model_name
        model_path
        initial_conditions
        state_names_with_nl
        state_types
        state_names
        derivative_names
        inport_names
        n_inports
        outport_names
        n_outports
        pre_trim
        output_names
        input_names

    end

    properties (Access = public)

        n_states
        n_outputs
        n_inputs
        parameters
        info_struct
        jaco_figure
        x
        u
        d
        y
        x_nam
        u_nam
        d_nam
        y_nam
        i_x
        i_u
        i_d
        i_y

    end

    methods (Access = private)

        % Save current table data in a specific file
        function save_trim_point (app, file_name)

            % Save the model name in the save structure
            save_struct = struct ('model_name', app.model_name);

            % Save all tables data in the save structure
            save_struct.input_data = app.UITable_input.Data;
            save_struct.state_data = app.UITable_state.Data;
            save_struct.derivative_data = app.UITable_derivative.Data;
            save_struct.output_data = app.UITable_output.Data;

            % Save the parameters in the save structure 
            save_struct.parameters = app.parameters;

            % Save the save structure
            % in the file defined in the parameter list
            save (file_name, 'save_struct');

        end

    end

    % Callbacks that handle component events
    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)

            % Initialize additional parameters
            app.parameters.n_iter_max = 42;
            app.parameters.cost_tbg = 1e-9;
            app.parameters.CompileFlag = 1;
            app.parameters.n_bisec_max = 10;
            app.parameters.EnableMessages = true;

            % Add TrimMod directory to the Matlab path
            addpath (cd);

            % Get the handle to the primary monitor 
            pri_mon = groot;

            % Get the position of the app
            % Default: [1, 50, 1920, 980]
            % Safety margin 50: Standard Windows taskbar height
            % 1920 x 1080: Full HD resolution (1080p)
            % 980: safety margin of 50 pixel extra space both at the bottom 
            % and at the top of the app figure
            win_pos = app.TrimModelUIFigure.Position;

            % If the app figure width is greater than the screen width 
            if win_pos(3) > pri_mon.ScreenSize(3)

                % set the app figure width to the screen width
                win_pos(3) = pri_mon.ScreenSize(3);
                app.TrimModelUIFigure.Position = win_pos;
            
            end

            % If the app figure height is greater than the screen height 
            % (including the safety margins) 
            if win_pos(4) > pri_mon.ScreenSize(4) - 100

                % set the app figure height to the (reduced) screen height
                win_pos(4) = pri_mon.ScreenSize(4) - 100;
                app.TrimModelUIFigure.Position = win_pos;

            end

        end

        % Callback function: ExitTrimModMenu, TrimModelUIFigure
        function ExitTrimModMenuSelected(app, event)

            % Ask the user if she wants to save the current trim point
            button_choice = uiconfirm ( ...
                app.TrimModelUIFigure, ...
                'Save trim point before exiting?', ...
                'Save trim point', ...
                'Options',{'Yes', 'No', 'Cancel'}, ...
                'DefaultOption', 1, ...
                'CancelOption', 3);

            % Action taken depends on the button pressed
            switch button_choice

                % If the "Cancel"-button has been pressed,
                case 'Cancel'

                    % do nothing
                    return

                    % If the "yes"-button has been pressed,
                case 'Yes'

                    % Call the "save_trim_point_as" function
                    SaveTrimPointasMenuSelected (app, event)

            end

            % Delete optional windows
            delete (app.parameters_app)
            delete (app.overview_app)
            delete (app.jaco_figure)

            % Delete the complete app
            delete (app)

        end

        % Menu selected function: AboutTrimModMenu
        function AboutTrimModMenuSelected(app, event)

            % Display the standard "About" dialog
            helpdlg ({ ...
                'TrimMod 2.2'; ...
                'Joerg J. Buchholz'; ...
                'Hochschule Bremen'; ...
                'buchholz@hs-bremen.de'}, ...
                'About TrimMod');

        end

        % Menu selected function: HelponTrimModMenu
        function HelponTrimModMenuSelected(app, event)

            % web ('https://m-server.fk5.hs-bremen.de/trimmod/trimmod.pdf')
            % web ('trimmod.pdf')
            open ('trimmod.pdf')

        end

        % Menu selected function: AdditionalParametersMenu
        function AdditionalParametersMenuSelected(app, event)

            % Open the parameters dialog app
            % and save it in a property
            % in order to delete it together with the TrimMod app later
            app.parameters_app = trimmod_parameters(app);

        end

        % Menu selected function: OpenModelMenu
        function OpenModelMenuSelected(app, event)

            % Open a file select box and save the selection
            [file_name, file_path] = uigetfile ('*.slx;*.mdl', 'Open Model');

            % Unfortunately, we have to bring back the app window to front
            % after a file select box.
            % This is a bug workaround that might be unnecessary in the future.
            figure (app.TrimModelUIFigure);

            % If the user has pressed the Cancel button,
            if ~file_name

                % do nothing
                return

            end

            % Extract the model name (without the file extension)
            % and save it in a property
            app.model_name = strtok (file_name, '.');

            % Extract the model path and save it without the trailing backslash
            app.model_path = file_path(1 : (end - 1));

            % Insert the model name in the name of the app
            app.TrimModelUIFigure.Name = ['Trim Model ', app.model_name];

            % Set the working directory to the model path
            cd (app.model_path);

            % Delete all state, inport, derivative, and outport names.
            % This is necessary if the previously opened model
            % had more states than the current.
            % Actually, it is only necessary for the derivatives
            % but well ...
            app.state_names = {};
            app.inport_names = {};
            app.derivative_names = {};
            app.outport_names = {};

            % Make sure the model is not compiled
            % ensureModelIsNotCompiled (app.model_name);

            % Open the main system block diagram internally
            % without bringing it to front.
            % This is only necessary for the next two commands
            load_system (app.model_name);

            % Uncheck (disable) the "Load Initial States" checkbox
            % in the "Configuration Parameters" menu entry of the current model.
            % This prevents an error if the user has changed the number of
            % states in the model since the last trim.
            set_param (app.model_name, 'LoadInitialState', 'off');

            % Uncheck (disable) the "Load Input from Workspace" checkbox
            % in the "Configuration Parameters" menu entry of the current model
            % This prevents an error if the user has changed the number of
            % inputs in the model since the last trim.
            set_param (app.model_name, 'LoadExternalInput', 'off');

            % Call model and save model parameters.
            % Since Release 11 (Version 5.3) the state names vector
            % might include newline characters.
            [sizes, app.initial_conditions, app.state_names_with_nl] = feval (app.model_name);

            % Save the number of states, inputs and outputs in properties
            app.n_states = sizes(1);
            app.n_outputs = sizes(3);
            app.n_inputs = sizes(4);

            % Find the block types of all states.
            % Valid types are 'Integrator', 'StateSpace', 'TransferFcn', 'ZeroPole', and 'S-Function'
            app.state_types = get_param (app.state_names_with_nl, 'blocktype');

            % Substitute the newline characters in the state names by blanks for better readability
            app.state_names = kill_nl (app.state_names_with_nl);

            % Loop over all the states
            for i_state = 1 : app.n_states

                % Strip the model name from the state names
                % in order to make the names easier to read in the table
                app.state_names{i_state} = app.state_names{i_state}(length (app.model_name) + 2 : end);

            end

            %% Uniquefy multiple state names

            % Loop over all the states
            for i_state = 1 : app.n_states

                % Find multiple state names and numbers of multiple state names
                matches = find (strcmp (app.state_names(i_state), app.state_names));
                n_matches = length (matches);

                % If multiple state names have been found
                if n_matches > 1

                    % Loop over all copies of a multiple state name
                    for i_match = 1 : n_matches

                        % Append "___1"," ___2", ... to every copy of a multiple state name
                        app.state_names{matches(i_match)} = ...
                            [app.state_names{matches(i_match)}, '___', num2str(i_match)];

                    end

                end

                % Derivatives get the words "Deriv. of" in front of their names
                % to make sure the user understands that these are the derivatives of the states
                app.derivative_names{i_state} = ['Deriv. of ', app.state_names{i_state}];

            end

            %% Inports

            % Compile the model.
            % We can only determine the port widths of compiled models
            feval (app.model_name, [], [], [], 'compile');

            % We have to distinguish between inports and inputs.
            % Vector inports have more than one input.

            % Find all inports (even in libraries: 'FollowLinks')
            app.inport_names = find_system (app.model_name, ...
                'FollowLinks', 'on', ...
                'searchdepth', 1, ...
                'Blocktype', 'Inport');

            % Save the number of inports
            app.n_inports = length (app.inport_names);

            % Initialize the input names cell array
            app.input_names = cell (app.n_inputs, 1);

            % Initialize the input index
            i_input = 1;

            % Loop over all inports
            for i_inport = 1 : app.n_inports

                % Get the number of inputs of the current inport
                % which are the "outports" of the inport ;-)
                n_inputs_of_port = get_param (app.inport_names{i_inport}, ...
                    'CompiledPortWidths').Outport;

                % Strip the model name from the port names
                % in order to make the names easier to read in the table
                app.inport_names{i_inport} = ...
                    app.inport_names{i_inport}(length (app.model_name) + 2 : end);

                % If the current inport is a vector inport
                % it belongs to more than one input
                if n_inputs_of_port > 1

                    % Loop over all inputs of the current inport
                    for i_inputs_of_port = 1 : n_inputs_of_port

                        % Append "___1"," ___2", ... to the input names
                        app.input_names{i_input} = ...
                            [app.inport_names{i_inport}, '___', num2str(i_inputs_of_port)];

                        % and increment the input index
                        i_input = i_input + 1;

                    end

                    % If the current inport is scalar
                else

                    % Simply copy the inport name to the input name
                    app.input_names{i_input} = app.inport_names{i_inport};

                    % and increment the input index
                    i_input = i_input + 1;

                end

            end


            %% Outports
            % We have to distinguish between outports and outputs.
            % Vector outports have more than one output.

            % Find all outports (even in libraries: 'FollowLinks')
            app.outport_names = find_system (app.model_name, ...
                'FollowLinks', 'on', ...
                'searchdepth', 1, ...
                'Blocktype', 'Outport');

            % Save the number of outports
            app.n_outports = length (app.outport_names);

            % Initialize the output names cell array
            app.output_names = cell (app.n_outputs, 1);

            % Initialize the output index
            i_output = 1;

            % Loop over all outports
            for i_outport = 1 : app.n_outports

                % Get the number of outputs of the current outport
                % which are the "inports" of the outport ;-)
                n_outputs_of_port = get_param (app.outport_names{i_outport}, 'CompiledPortWidths').Inport;

                % Strip the model name from the port names
                % in order to make the names easier to read in the table
                app.outport_names{i_outport} = app.outport_names{i_outport}(length (app.model_name) + 2 : end);

                % If the current outport is a vector outport
                % it belongs to more than one output
                if n_outputs_of_port > 1

                    % Loop over all outputs of the current outport
                    for i_outputs_of_port = 1 : n_outputs_of_port

                        % Append "___1"," ___2", ... to the output names
                        app.output_names{i_output} = [app.outport_names{i_outport}, '___', num2str(i_outputs_of_port)];

                        % and increment the output index
                        i_output = i_output + 1;

                    end

                    % If the current outport is scalar
                else

                    % Simply copy the outport name to the output name
                    app.output_names{i_output} = app.outport_names{i_outport};

                    % and increment the output index
                    i_output = i_output + 1;

                end

            end

            % Terminate the simulation initiated by ... 'compile'.
            feval (app.model_name, [], [], [], 'term');

            % Initialize all table cells with zeros
            app.UITable_input.Data = num2cell (zeros (app.n_inputs, 7));
            app.UITable_state.Data = num2cell (zeros (app.n_states, 7));
            app.UITable_derivative.Data = num2cell (zeros (app.n_states, 3));
            app.UITable_output.Data = num2cell (zeros (app.n_outputs, 3));

            % Uncheck all state check boxes
            app.UITable_input.Data(:, 3) = num2cell (false (app.n_inputs, 1));
            app.UITable_state.Data(:, 3) = num2cell (false (app.n_states, 1));
            app.UITable_derivative.Data(:, 3) = num2cell (false (app.n_states, 1));
            app.UITable_output.Data(:, 3) = num2cell (false (app.n_outputs, 1));

            % Write the input, state, derivative, and output names
            % into the corresponding tables
            app.UITable_input.Data(:, 1) = kill_nl (app.input_names);
            app.UITable_state.Data(:, 1) = app.state_names;
            app.UITable_derivative.Data(:, 1) = app.derivative_names;
            app.UITable_output.Data(:, 1) = kill_nl (app.output_names);

            % Write the state types into the last column of the state table
            app.UITable_state.Data(:, 8) = app.state_types;

            % Update number of trim variables and trim requirements
            update (app, [])

            % Enable appropriate menu entries
            app.LoadTrimPointMenu.Enable = true;
            app.SaveTrimPointMenu.Enable = true;
            app.SaveTrimPointasMenu.Enable = true;

            % Append model name to menu entry "Save Trim Point in ..."
            app.SaveTrimPointMenu.Text = ...
                ['&Save Trim Point in ', app.model_name, '.mat'];

        end

        % Cell edit callback: UITable_derivative, UITable_input, 
        % UITable_output, UITable_state
        function update(app, event)

            % The number of trim variables is the sum of
            % all checked inputs and states.
            n_trim_variables = ...
                sum (cell2mat (app.UITable_input.Data(:, 3))) + ...
                sum (cell2mat (app.UITable_state.Data(:, 3)));

            % Indicate the number of trim variables
            % in the corresponding label.
            app.TrimVariablesLabel.Text = ['Trim Variables (', num2str(n_trim_variables), ')'];

            % The number of trim requirements is the sum of
            % all checked derivatives and outputs.
            n_trim_requirements = ...
                sum (cell2mat (app.UITable_derivative.Data(:, 3))) + ...
                sum (cell2mat (app.UITable_output.Data(:, 3)));

            % Indicate the number of trim requirements
            % in the corresponding label.
            app.TrimRequirementsLabel.Text = ['Trim Requirements (', num2str(n_trim_requirements), ')'];

            % If there is an equal number of
            % trim variables and trim requirements
            if n_trim_variables == n_trim_requirements

                % Paint the corresponding labels black
                app.TrimVariablesLabel.FontColor = 'black';
                app.TrimRequirementsLabel.FontColor = 'black';

                % and enable the Trim menu entry
                app.TrimMenu.Enable = true;

                % If there is an unequal number of
                % trim variables and trim requirements
            else

                % Paint the corresponding labels red
                app.TrimVariablesLabel.FontColor = 'red';
                app.TrimRequirementsLabel.FontColor = 'red';

                % and disable the Trim menu entry
                app.TrimMenu.Enable = false;

            end

        end

        % Menu selected function: SaveTrimPointMenu
        function SaveTrimPointMenuSelected(app, event)

            % Save the trim point in the default file
            save_trim_point (app, app.model_name)

        end

        % Menu selected function: SaveTrimPointasMenu
        function SaveTrimPointasMenuSelected(app, event)

            % Open a file select box and let the user decide where to save the trim point
            [file_name, file_path] = uiputfile ([app.model_name, '.mat'], 'Save Trim Point As');

            % Unfortunatly, we have to bring back the app window to front
            % after using a file select box.
            % This bug workaoroud will hopefully be unnecessary in the future.
            figure (app.TrimModelUIFigure);

            % If the user has pressed the cancel button,
            if ~file_name

                % do nothing
                return

            end

            % Save the trim point in the user defined file
            save_trim_point (app, [file_path, file_name]);

        end

        % Menu selected function: LoadTrimPointMenu
        function LoadTrimPointMenuSelected(app, event)

            % Open a file select box and let the user decide which trim point to load
            [file_name, file_path] = uigetfile ('*.mat', 'Load Trim Point');

            % Unfortunatly, we have to bring back the app window to front
            % after a file select box.
            % This is a bug workaoroud that might be unnecessary in the future.
            figure (app.TrimModelUIFigure);

            % If the user has pressed the cancel button,
            if ~file_name

                % do nothing
                return

            end

            % Load new trim point
            load ([file_path, file_name], 'save_struct');

            %% Parameters

            % Update current parameters with loaded data
            app.parameters = save_struct.parameters;

            %% Inputs

            % Find those rows with identical names
            % in loaded data and current table
            [~, rows_loaded, rows_current] = intersect (save_struct.input_data(:, 1), app.UITable_input.Data(:, 1));

            % Update only those rows with identical names
            app.UITable_input.Data(rows_current, :) = save_struct.input_data(rows_loaded, :);

            %% States

            % Find those rows with identical  names
            % in loaded data and current table
            [~, rows_loaded, rows_current] = intersect (save_struct.state_data(:, 1), app.UITable_state.Data(:, 1));

            % Update only those rows with identical names
            app.UITable_state.Data(rows_current, :) = save_struct.state_data(rows_loaded, :);

            %% Derviatives

            % Find those rows with identical names
            % in loaded data and current table
            [~, rows_loaded, rows_current] = intersect (save_struct.derivative_data(:, 1), app.UITable_derivative.Data(:, 1));

            % Update only those rows with identical names
            app.UITable_derivative.Data(rows_current, :) = save_struct.derivative_data(rows_loaded, :);

            %% Outputs

            % Find those rows with identical names
            % in loaded data and current table
            [~, rows_loaded, rows_current] = intersect (save_struct.output_data(:, 1), app.UITable_output.Data(:, 1));

            % Update only those rows with identical names
            app.UITable_output.Data(rows_current, :) = save_struct.output_data(rows_loaded, :);

            %% Inform user

            % Create a cell array containing all input, state, and output
            % names from the loaded data
            loaded = union (union ( ...
                save_struct.input_data(:, 1), ...
                save_struct.state_data(:, 1)), ...
                save_struct.output_data(:, 1));

            % Create a cell array containing all input, state, and output
            % names from the current model
            current = union (union ( ...
                app.UITable_input.Data(:, 1), ...
                app.UITable_state.Data(:, 1)),  ...
                app.UITable_output.Data(:, 1));

            % Find those names that are present in the loaded data
            % but not in the current model
            loaded_without_current = setdiff (loaded, current);

            % If there are more names in the loaded data
            if ~isempty (loaded_without_current)

                % inform the user
                warndlg ([ ...
                    'The following names are present in the file', ...
                    newline, ...
                    file_name, ...
                    newline, ...
                    'but not in the model', ...
                    newline, ...
                    app.model_name, ...
                    ':'; ...
                    loaded_without_current; ...
                    'I have just loaded the intersection of the sets.'], ...
                    'Warning')

            end

            % Find those names that are present in the current model
            % but not in the loaded data
            current_without_loaded = setdiff (current, loaded);

            % If there are more names in the current table,
            if ~isempty (current_without_loaded)

                % inform the user
                warndlg ([ ...
                    'The following names are present in the model', ...
                    newline, ...
                    app.model_name, ...
                    newline, ...
                    'but not in the file', ...
                    newline, ...
                    file_name, ...
                    ':'; ...
                    current_without_loaded; ...
                    'I have just loaded the intersection of the sets.'], ...
                    'Warning')

            end

            % Update number of trim variables and trim requirements
            update (app, [])

        end

        % Cell selection callback: UITable_derivative, UITable_input, 
        % UITable_output, UITable_state
        function selection(app, event)

            % Find the indices of the selected table element
            indizes = event.Indices;

            % If the user selected a name (in the first column)
            if indizes(2) == 1

                % Buffer the name of the selected element
                block_to_open = event.Source.Data{indizes(1), 1};

                % In order to get rid of potential "___1", "___2", ...
                % of vector states, split (those) at "____"
                block_to_open = split (block_to_open, '___');

                % After splitting, just take the first part and
                % ignore the second part (the "___1", "___2", ...)
                block_to_open = block_to_open{1};

                % Elements in the Derivative table contain "Deriv. of "
                % which is not part of the block name.
                block_to_open = erase (block_to_open, 'Deriv. of ');

                % Finally, add the model name to the block to be opened
                block_to_open = [app.model_name, '/', block_to_open];

                % Find the indices of all slashes in the name of the block to be opened
                slashes = strfind (block_to_open, '/');

                % Find the index of the last slash
                last_slash = slashes (end);

                % The system to be opened is the whole path to the block to be opened
                % up to the last slash.
                system_to_open = block_to_open(1 : last_slash - 1);

                % The system has to be loaded before it can be opened.
                load_system (app.model_name)

                % Open the block diagram containing the block to be opened
                open_system (system_to_open);

                % Blink five times
                for i_blink = 1 : 5

                    % Cycle selection between on and off
                    for selection = {'on', 'off'}

                        % Switch selection
                        set_param (block_to_open, 'Selected', selection{1})

                        % Wait 100 ms
                        pause (0.1)

                    end

                end

            end
        end

        % Menu selected function: TrimMenu
        function TrimMenuSelected(app, event)

            % Copy the values of the states, inputs, derivatives, and outputs
            % to the variables x, u, d, and y
            app.x = cell2mat (app.UITable_state.Data(:, 2));
            app.u = cell2mat (app.UITable_input.Data(:, 2));
            app.d = cell2mat (app.UITable_derivative.Data(:, 2));
            app.y = cell2mat (app.UITable_output.Data(:, 2));

            % Find the indices of all trim variables and trim requirements
            app.i_x = find (cell2mat (app.UITable_state.Data(:, 3)));
            app.i_u = find (cell2mat (app.UITable_input.Data(:, 3)));
            app.i_d = find (cell2mat (app.UITable_derivative.Data(:, 3)));
            app.i_y = find (cell2mat (app.UITable_output.Data(:, 3)));

            % Find the names of inputs, states, derivatives and outputs
            app.x_nam = app.UITable_state.Data(:, 1);
            app.u_nam = app.UITable_input.Data(:, 1);
            app.d_nam = app.UITable_derivative.Data(:, 1);
            app.y_nam = app.UITable_output.Data(:, 1);

            % Get the values for "Maximum Trim Step"
            del_x_max = cell2mat (app.UITable_state.Data(:, 4));
            del_u_max = cell2mat (app.UITable_input.Data(:, 4));

            % Replace every zero-element in "Maximum Trim Step"
            % with the default value (1e42)
            del_x_max(~del_x_max) = 1e42;
            del_u_max(~del_u_max) = 1e42;

            % Get the values for "Linearization Step"
            del_x_lin = cell2mat (app.UITable_state.Data(:, 5));
            del_u_lin = cell2mat (app.UITable_input.Data(:, 5));

            % Replace every zero-element in "Linearization Step"
            % with the default value (1e-6*(1+abs(...)))
            del_x_lin(~del_x_lin) = 1e-6 * (1 + abs (app.x(~del_x_lin)));
            del_u_lin(~del_u_lin) = 1e-6 * (1 + abs (app.u(~del_u_lin)));

            % Get the values for "Minimum Value"
            x_min = cell2mat (app.UITable_state.Data(:, 6));
            u_min = cell2mat (app.UITable_input.Data(:, 6));

            % Replace every zero-element in "Minimum Value"
            % with the default value (-inf)
            x_min(~x_min) = -inf;
            u_min(~u_min) = -inf;

            % Get the values for "Maximum Value"
            x_max = cell2mat (app.UITable_state.Data(:, 7));
            u_max = cell2mat (app.UITable_input.Data(:, 7));

            % Replace every zero-element in "Maximum Value"
            % with the default value (inf)
            x_max(~x_max) = inf;
            u_max(~u_max) = inf;

            % Save the "old" (pre-trim) variables in a structure
            app.pre_trim.state = app.UITable_state.Data(:, 2);
            app.pre_trim.input = app.UITable_input.Data(:, 2);
            app.pre_trim.derivative = app.UITable_derivative.Data(:, 2);
            app.pre_trim.output = app.UITable_output.Data(:, 2);

            % Call the actual trim algorithm
            [x_tr, u_tr, d_tr, y_tr, ~, app.info_struct] = jj_trim ( ...
                app.model_name, ...
                app.x, app.u, app.d, app.y, ...
                app.i_x, app.i_u, app.i_d, app.i_y, ...
                app.x_nam, app.u_nam, app.d_nam, app.y_nam, ...
                del_x_max, del_u_max, del_x_lin, del_u_lin, ...
                app.parameters, ...
                x_min, x_max, u_min, u_max);

            if ~isempty (app.info_struct)

                % Enable the "Untrim" and the "Show Overview" menu entry
                app.UntrimMenu.Enable = true;
                app.ShowOverviewMenu.Enable = true;

            end

            % Copy the trimmed states, inputs, derivatives, and outputs
            % back into the corresponding tables
            app.UITable_state.Data(:, 2) = num2cell (x_tr);
            app.UITable_input.Data(:, 2) = num2cell (u_tr);
            app.UITable_derivative.Data(:, 2) = num2cell (d_tr);
            app.UITable_output.Data(:, 2) = num2cell (y_tr);

            %% Transfer trim point to model

            % In oder to automatically transfer the trim point to the current
            % model, we can use the "Input" and "Initial state" edit texts
            % in the "Modeling > Model Settings> Data Import/Export >
            % Configuration Parameters > Load from workspace"
            % menu entry of the model.
            %
            % Unfortunately, Simulink has claimed the right to alter the
            % order of the states during the simulation. Therefore, we
            % cannot simply use the trimmed state vector (x_tr)
            % but we have to convert the vector to a structure
            % that additionally features the corresponding state names.
            %
            % In order to save the trim point together with the model,
            % we save the trim point in the model workspace.

            % Add a "time span" of zero to the input trim vector
            u_tr_with_zero = [0, u_tr'];

            % Convert the state trim vector to a string, with maximum precision.
            % A postulated precision of 42 seems to result in more significant(?) digits
            % than the recommended version without any postulated precision.
            x_tr_string = mat2str (x_tr, 42);

            % Check (Enable) the "Initial state" checkbox
            % and the "Input" checkbox
            % in the "Load from Workspace" menu entry of the current model
            set_param (app.model_name, 'LoadInitialState', 'on');
            set_param (app.model_name, 'LoadExternalInput', 'on');

            % Transfer the state trim vector to the "Initial State" edit
            % text
            set_param (app.model_name, 'InitialState', x_tr_string);

            % Set the Format of the state vector to "Structure"
            set_param (app.model_name, 'SaveFormat', 'Structure');

            % Retrieve the trimmed initial state as a structure
            x_tr_structure = Simulink.BlockDiagram.getInitialState (app.model_name);

            % Access the model workspace
            model_workspace = get_param (app.model_name, 'ModelWorkspace');

            % Save the initial input trim vector and the state trim structure
            % in the model workspace
            assignin (model_workspace, 'initial_input_in_model_workspace', u_tr_with_zero)
            assignin (model_workspace, 'initial_state_in_model_workspace', x_tr_structure)

            % Transfer the names of the input trim vector and the state trim structure
            % saved in the model workspace
            % to the corresponding edit texts
            % in the "Load from workspace" menu entry of the current model.
            set_param (app.model_name, 'ExternalInput', 'initial_input_in_model_workspace');
            set_param (app.model_name, 'InitialState', 'initial_state_in_model_workspace');
        end

        % Menu selected function: UntrimMenu
        function UntrimMenuSelected(app, event)

            % Disable the "Untrim" menu entry.
            % Only one untrim is possible.
            app.UntrimMenu.Enable = false;

            % Copy the pre-trim states, inputs, derivatives, and outputs
            % into the corresponding tables
            app.UITable_state.Data(:, 2) = app.pre_trim.state;
            app.UITable_input.Data(:, 2) = app.pre_trim.input;
            app.UITable_derivative.Data(:, 2) = app.pre_trim.derivative;
            app.UITable_output.Data(:, 2) = app.pre_trim.output;

        end

        % Menu selected function: ShowOverviewMenu
        function ShowOverviewMenuSelected(app, event)

            % Delete a potentially open overview app
            delete (app.overview_app);

            % Open a new overview app
            app.overview_app = trimmod_overview (app);

        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.TrimModelUIFigure = uifigure('Visible', 'off');
            app.TrimModelUIFigure.Name = 'Trim Model';
            app.TrimModelUIFigure.Icon = '42.png';
            app.TrimModelUIFigure.CloseRequestFcn = createCallbackFcn(app, @ExitTrimModMenuSelected, true);
            app.FileMenu = uimenu(app.TrimModelUIFigure);
            app.FileMenu.Text = 'File';
            app.OpenModelMenu = uimenu(app.FileMenu);
            app.OpenModelMenu.MenuSelectedFcn = createCallbackFcn(app, @OpenModelMenuSelected, true);
            app.OpenModelMenu.Text = 'Open Model';
            app.LoadTrimPointMenu = uimenu(app.FileMenu);
            app.LoadTrimPointMenu.MenuSelectedFcn = createCallbackFcn(app, @LoadTrimPointMenuSelected, true);
            app.LoadTrimPointMenu.Enable = 'off';
            app.LoadTrimPointMenu.Separator = 'on';
            app.LoadTrimPointMenu.Text = 'Load Trim Point';
            app.SaveTrimPointMenu = uimenu(app.FileMenu);
            app.SaveTrimPointMenu.MenuSelectedFcn = createCallbackFcn(app, @SaveTrimPointMenuSelected, true);
            app.SaveTrimPointMenu.Enable = 'off';
            app.SaveTrimPointMenu.Text = 'Save Trim Point';
            app.SaveTrimPointasMenu = uimenu(app.FileMenu);
            app.SaveTrimPointasMenu.MenuSelectedFcn = createCallbackFcn(app, @SaveTrimPointasMenuSelected, true);
            app.SaveTrimPointasMenu.Enable = 'off';
            app.SaveTrimPointasMenu.Text = 'Save Trim Point as';
            app.ExitTrimModMenu = uimenu(app.FileMenu);
            app.ExitTrimModMenu.MenuSelectedFcn = createCallbackFcn(app, @ExitTrimModMenuSelected, true);
            app.ExitTrimModMenu.Separator = 'on';
            app.ExitTrimModMenu.Text = 'Exit TrimMod';
            app.ActionMenu = uimenu(app.TrimModelUIFigure);
            app.ActionMenu.Text = 'Action';
            app.TrimMenu = uimenu(app.ActionMenu);
            app.TrimMenu.MenuSelectedFcn = createCallbackFcn(app, @TrimMenuSelected, true);
            app.TrimMenu.Enable = 'off';
            app.TrimMenu.Text = 'Trim';
            app.UntrimMenu = uimenu(app.ActionMenu);
            app.UntrimMenu.MenuSelectedFcn = createCallbackFcn(app, @UntrimMenuSelected, true);
            app.UntrimMenu.Enable = 'off';
            app.UntrimMenu.Text = 'Untrim';
            app.OptionsMenu = uimenu(app.TrimModelUIFigure);
            app.OptionsMenu.Text = 'Options';
            app.AdditionalParametersMenu = uimenu(app.OptionsMenu);
            app.AdditionalParametersMenu.MenuSelectedFcn = createCallbackFcn(app, @AdditionalParametersMenuSelected, true);
            app.AdditionalParametersMenu.Text = 'Additional Parameters';
            app.ShowOverviewMenu = uimenu(app.OptionsMenu);
            app.ShowOverviewMenu.MenuSelectedFcn = createCallbackFcn(app, @ShowOverviewMenuSelected, true);
            app.ShowOverviewMenu.Enable = 'off';
            app.ShowOverviewMenu.Text = 'Show Overview';
            app.HelpMenu = uimenu(app.TrimModelUIFigure);
            app.HelpMenu.Text = 'Help';
            app.HelponTrimModMenu = uimenu(app.HelpMenu);
            app.HelponTrimModMenu.MenuSelectedFcn = createCallbackFcn(app, @HelponTrimModMenuSelected, true);
            app.HelponTrimModMenu.Text = 'Help on TrimMod';
            app.AboutTrimModMenu = uimenu(app.HelpMenu);
            app.AboutTrimModMenu.MenuSelectedFcn = createCallbackFcn(app, @AboutTrimModMenuSelected, true);
            app.AboutTrimModMenu.Separator = 'on';
            app.AboutTrimModMenu.Text = 'About TrimMod';
            app.GridLayout = uigridlayout(app.TrimModelUIFigure);
            app.GridLayout.Tooltip = {''};
            app.UITable_input = uitable(app.GridLayout);
            app.UITable_input.ColumnName = {'Input'; 'Value'; 'Trim|Variable'; 'Max.|Trim Step'; 'Linear.|Step'; 'Min.|Value'; 'Max.|Value'};
            app.UITable_input.RowName = {};
            app.UITable_input.ColumnEditable = [false true true true true true true];
            app.UITable_input.CellEditCallback = createCallbackFcn(app, @update, true);
            app.UITable_input.CellSelectionCallback = createCallbackFcn(app, @selection, true);
            app.UITable_input.Tooltip = {''};
            app.TrimVariablesLabel = uilabel(app.GridLayout);
            app.TrimVariablesLabel.Text = 'Trim Variables (0)';
            app.TrimRequirementsLabel = uilabel(app.GridLayout);
            app.TrimRequirementsLabel.Text = 'Trim Requirements (0)';
            app.UITable_state = uitable(app.GridLayout);
            app.UITable_state.ColumnName = {'State'; 'Value'; 'Trim|Variable'; 'Max.|Trim Step'; 'Linear.|Step'; 'Min.|Value'; 'Max.|Value'; 'Type'};
            app.UITable_state.RowName = {};
            app.UITable_state.ColumnEditable = [false true true true true true true false];
            app.UITable_state.CellEditCallback = createCallbackFcn(app, @update, true);
            app.UITable_state.CellSelectionCallback = createCallbackFcn(app, @selection, true);
            app.UITable_state.Tooltip = {''};
            app.UITable_derivative = uitable(app.GridLayout);
            app.UITable_derivative.ColumnName = {'Derivative'; 'Value'; 'Trim|Requirement'};
            app.UITable_derivative.RowName = {};
            app.UITable_derivative.ColumnEditable = [false true true];
            app.UITable_derivative.CellEditCallback = createCallbackFcn(app, @update, true);
            app.UITable_derivative.CellSelectionCallback = createCallbackFcn(app, @selection, true);
            app.UITable_derivative.Tooltip = {''};
            app.UITable_output = uitable(app.GridLayout);
            app.UITable_output.ColumnName = {'Output'; 'Value'; 'Trim|Requirement'};
            app.UITable_output.RowName = {};
            app.UITable_output.ColumnEditable = [false true true];
            app.UITable_output.CellEditCallback = createCallbackFcn(app, @update, true);
            app.UITable_output.CellSelectionCallback = createCallbackFcn(app, @selection, true);
            app.UITable_output.Tooltip = {''};
            % Show the figure after all components are created
            app.TrimModelUIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = trimmod

            runningApp = getRunningApp(app);

            % Check for running singleton app
            if isempty(runningApp)

                % Create UIFigure and components
                createComponents(app)

                % Register the app with App Designer
                registerApp(app, app.TrimModelUIFigure)

                % Execute the startup function
                runStartupFcn(app, @startupFcn)
            else

                % Focus the running singleton app
                figure(runningApp.TrimModelUIFigure)

                app = runningApp;
            end

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.TrimModelUIFigure)
        end
    end
end