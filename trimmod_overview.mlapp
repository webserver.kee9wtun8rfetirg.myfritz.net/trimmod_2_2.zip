classdef trimmod_overview < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        TrimModOverviewUIFigure  matlab.ui.Figure
        UITable                  matlab.ui.control.Table
    end


    properties (Access = private)

        trimmod

    end


    % Callbacks that handle component events
    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app, trimmod)

            % Save the name of the calling app in a property
            % in order to allow the CellSelection function
            % to access the public properties of trimmod directly.
            app.trimmod = trimmod;

            % Position the Overview figure "over" the TrimMod figure
            app.TrimModOverviewUIFigure.Position = app.trimmod.TrimModelUIFigure.Position;

            % Fill the whole Overview figure with the Overview table
            app.UITable.Position = [ ...
                1, ...
                1, ...
                app.TrimModOverviewUIFigure.Position(3), ...
                app.TrimModOverviewUIFigure.Position(4)];

            % Get the number of iterations from trimmod
            n_iter = trimmod.info_struct.n_iter;

            % The heading of the first (name) column is static.
            app.UITable.ColumnName{1} = 'States, Inputs, Derivatives, Outputs, Cost, ...';

            % Loop over all iterations
            for i_iter = 0 : n_iter

                % Generate the headings of the data columns dynamically
                app.UITable.ColumnName{i_iter + 2} = ['Iteration ', num2str(i_iter)];

            end

            % Construct the names column
            names = [ ...
                trimmod.x_nam; ...
                trimmod.u_nam; ...
                trimmod.d_nam; ...
                trimmod.y_nam; ...
                'Cost function'; ...
                'Step type'; ...
                'Bisection counter'; ...
                'Step limitation'; ...
                'Jacobian'];

            % Initialize the content of the table as a cell array
            app.UITable.Data = cell (numel (names), n_iter + 2);

            % Use names as the first table column
            app.UITable.Data(:, 1) = names;

            % Prepare the remaining table data.
            % Unfortunately, in the current version,
            % integers in a uifigure based uitable
            % are displayed as doubles (with four decimal places)
            % if the uitable contains another double.
            % Therefore, StepType, BisecCounter, and LimitedStep
            % are displayed as doubles. :-(
            data = num2cell ([ ...
                trimmod.info_struct.x; ...
                trimmod.info_struct.u; ...
                trimmod.info_struct.d; ...
                trimmod.info_struct.y; ...
                trimmod.info_struct.cost; ...
                0, trimmod.info_struct.StepType; ...
                0, trimmod.info_struct.BisecCounter; ...
                0, trimmod.info_struct.LimitedStep]);

            % The last row of the table shall contain 'Click me' buttons.
            % If there is no iteration because the initial Jacobian is
            % singular,
            if n_iter == 0

                % we just need one button for the initial Jacobian
                data = [data; {'Click me!'}];

                % If there are iterations,
            else

                % the last iteration does not return a Jacobian
                data = [data; repmat({'Click me!'}, 1, n_iter), {''}];

            end

            % Insert the prepared data into the table
            app.UITable.Data(:, 2 : end) = data;

        end

        % Cell selection callback: UITable
        function UITableCellSelection(app, event)

            % Buffer the row and column index
            % of the currently selected cell
            indices = event.Indices;

            % If the user has selected one of the 'Click me' buttons
            if strcmp (app.UITable.Data{indices(1), indices(2)}, 'Click me!')

                % Delete a potentially open Jacobian figure
                delete (app.trimmod.jaco_figure)

                % Open a new figure to display the current Jacobian.
                % Move its lower left vertex 100 pixel up
                % with respect to the lower left vertex of the Overview
                % figure, in order to keep the "Click me" row visible.
                app.trimmod.jaco_figure = uifigure ('Position', [ ...
                    app.TrimModOverviewUIFigure.Position(1), ...
                    app.TrimModOverviewUIFigure.Position(2) + 100, ...
                    app.TrimModOverviewUIFigure.Position(3), ...
                    app.TrimModOverviewUIFigure.Position(4) - 100]);

                % Adjust the figure title
                app.trimmod.jaco_figure.Name = ['Jacobian at iteration step ', num2str(indices(2)) - 2];

                % Create a new table
                % and fill the whole Jacobian figure with the Jacobian table
                table_jaco = uitable (app.trimmod.jaco_figure, ...
                    'Position', [ ...
                    1, ...
                    1, ...
                    app.trimmod.jaco_figure.Position(3), ...
                    app.trimmod.jaco_figure.Position(4)]);

                % Build the generalized input names vector
                % by concatenation of the state names and the input names
                x_u_nam = [app.trimmod.x_nam; app.trimmod.u_nam];

                % and the generalized output names vector
                % by concatenation of the derivative names and the output names
                d_y_nam = [app.trimmod.d_nam; app.trimmod.y_nam];

                % Find the indices of the trim variables
                % in the generalized input names vector
                index_trim_variables = [app.trimmod.i_x; length(app.trimmod.x) + app.trimmod.i_u];

                % Find the indices of the trim requirements
                % in the generalized output names vector
                index_trim_requirements = [app.trimmod.i_d; length(app.trimmod.d) + app.trimmod.i_y];

                % Use the current jacobi matrix as the data of the table
                table_jaco.Data = num2cell (app.trimmod.info_struct.jaco{indices(2) - 1});

                % Use the names of the trim requirements
                % as the row names of the table
                table_jaco.RowName = d_y_nam (index_trim_requirements);

                % Use the names of the trim variables
                % as the column names of the table
                table_jaco.ColumnName = x_u_nam (index_trim_variables);

                % Give all columns equal width
                table_jaco.ColumnWidth = '1x';

            end

        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.TrimModOverviewUIFigure = uifigure('Visible', 'off');
            app.TrimModOverviewUIFigure.Name = 'TrimMod Overview';
            app.TrimModOverviewUIFigure.Icon = '42.png';
            app.UITable = uitable(app.TrimModOverviewUIFigure);
            app.UITable.ColumnName = '';
            app.UITable.RowName = {};
            app.UITable.CellSelectionCallback = createCallbackFcn(app, @UITableCellSelection, true);
            % Show the figure after all components are created
            app.TrimModOverviewUIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = trimmod_overview(varargin)

            runningApp = getRunningApp(app);

            % Check for running singleton app
            if isempty(runningApp)

                % Create UIFigure and components
                createComponents(app)

                % Register the app with App Designer
                registerApp(app, app.TrimModOverviewUIFigure)

                % Execute the startup function
                runStartupFcn(app, @(app)startupFcn(app, varargin{:}))
            else

                % Focus the running singleton app
                figure(runningApp.TrimModOverviewUIFigure)

                app = runningApp;
            end

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.TrimModOverviewUIFigure)
        end
    end
end