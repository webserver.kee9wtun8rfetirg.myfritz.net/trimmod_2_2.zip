classdef trimmod_parameters < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        TrimModParametersUIFigure     matlab.ui.Figure
        CancelButton                  matlab.ui.control.Button
        OkayButton                    matlab.ui.control.Button
        EnablemessageboxesandconsolemessagesCheckBox  matlab.ui.control.CheckBox
        CompilationDropDown           matlab.ui.control.DropDown
        CompilationDropDownLabel      matlab.ui.control.Label
        MaximumnumberofbisectionsEditField  matlab.ui.control.NumericEditField
        MaximumnumberofbisectionsEditFieldLabel  matlab.ui.control.Label
        CosttobegainedEditField       matlab.ui.control.NumericEditField
        CosttobegainedEditFieldLabel  matlab.ui.control.Label
        MaximumnumberofiterationsEditField  matlab.ui.control.NumericEditField
        MaximumnumberofiterationsEditFieldLabel  matlab.ui.control.Label
    end

    properties (Access = private)
        
        trimmod 
    
    end

    % Callbacks that handle component events
    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app, trimmod)
            
            % Save the name of the calling app in a property
            % in order to allow the OkayButton function 
            % to access the public properties of trimmod directly.
            app.trimmod = trimmod;
            
            % Move the lower left vertex of the parameters dialog figure 
            % to the lower left vertex of the TrimMod figure
            app.TrimModParametersUIFigure.Position(1 : 2) = app.trimmod.TrimModelUIFigure.Position(1 : 2);
            
            % Populate the EditFields, the DropDownList, and the CheckBox 
            % with the values from the calling app 
            app.MaximumnumberofiterationsEditField.Value = trimmod.parameters.n_iter_max;
            app.CosttobegainedEditField.Value = trimmod.parameters.cost_tbg;
            app.CompilationDropDown.Value = trimmod.parameters.CompileFlag;
            app.MaximumnumberofbisectionsEditField.Value = trimmod.parameters.n_bisec_max;
            app.EnablemessageboxesandconsolemessagesCheckBox.Value = trimmod.parameters.EnableMessages;
            
        end

        % Button pushed function: OkayButton
        function OkayButtonPushed(app, event)
            
            % Write the values from the EditFields, the DropDownList, and the CheckBox
            % back to the calling app
            app.trimmod.parameters.n_iter_max = app.MaximumnumberofiterationsEditField.Value;
            app.trimmod.parameters.cost_tbg = app.CosttobegainedEditField.Value;
            app.trimmod.parameters.CompileFlag = app.CompilationDropDown.Value;
            app.trimmod.parameters.n_bisec_max = app.MaximumnumberofbisectionsEditField.Value;
            app.trimmod.parameters.EnableMessages = app.EnablemessageboxesandconsolemessagesCheckBox.Value;
            
            % Delete this app
            delete (app)
            
        end

        % Button pushed function: CancelButton
        function CancelButtonPushed(app, event)
                        
            % Delete this app
            delete (app)
            
        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.TrimModParametersUIFigure = uifigure('Visible', 'off');
            app.TrimModParametersUIFigure.Name = 'TrimMod Parameters';
            app.TrimModParametersUIFigure.Icon = '42.png';
            app.MaximumnumberofiterationsEditFieldLabel = uilabel(app.TrimModParametersUIFigure);
            app.MaximumnumberofiterationsEditFieldLabel.Text = 'Maximum number of iterations';
            app.MaximumnumberofiterationsEditField = uieditfield(app.TrimModParametersUIFigure, 'numeric');
            app.MaximumnumberofiterationsEditField.Limits = [0 Inf];
            app.CosttobegainedEditFieldLabel = uilabel(app.TrimModParametersUIFigure);
            app.CosttobegainedEditFieldLabel.Text = 'Cost to be gained';
            app.CosttobegainedEditField = uieditfield(app.TrimModParametersUIFigure, 'numeric');
            app.MaximumnumberofbisectionsEditFieldLabel = uilabel(app.TrimModParametersUIFigure);
            app.MaximumnumberofbisectionsEditFieldLabel.Text = 'Maximum number of bisections';
            app.MaximumnumberofbisectionsEditField = uieditfield(app.TrimModParametersUIFigure, 'numeric');
            app.CompilationDropDownLabel = uilabel(app.TrimModParametersUIFigure);
            app.CompilationDropDownLabel.Text = 'Compilation';
            app.CompilationDropDown = uidropdown(app.TrimModParametersUIFigure);
            app.CompilationDropDown.Items = {'Model must be precompiled', 'Compile model with ''compile''', 'Compile model with ''lincompile'''};
            app.CompilationDropDown.ItemsData = [0 1 2];
            app.CompilationDropDown.Value = 1;
            app.EnablemessageboxesandconsolemessagesCheckBox = uicheckbox(app.TrimModParametersUIFigure);
            app.EnablemessageboxesandconsolemessagesCheckBox.Text = 'Enable message boxes and console messages';
            app.OkayButton = uibutton(app.TrimModParametersUIFigure, 'push');
            app.OkayButton.ButtonPushedFcn = createCallbackFcn(app, @OkayButtonPushed, true);
            app.OkayButton.Text = 'Okay';
            app.CancelButton = uibutton(app.TrimModParametersUIFigure, 'push');
            app.CancelButton.ButtonPushedFcn = createCallbackFcn(app, @CancelButtonPushed, true);
            app.CancelButton.Text = 'Cancel';
            % Show the figure after all components are created
            app.TrimModParametersUIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = trimmod_parameters(varargin)

            runningApp = getRunningApp(app);

            % Check for running singleton app
            if isempty(runningApp)

                % Create UIFigure and components
                createComponents(app)

                % Register the app with App Designer
                registerApp(app, app.TrimModParametersUIFigure)

                % Execute the startup function
                runStartupFcn(app, @(app)startupFcn(app, varargin{:}))
            else

                % Focus the running singleton app
                figure(runningApp.TrimModParametersUIFigure)

                app = runningApp;
            end

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.TrimModParametersUIFigure)
        end
    end
end